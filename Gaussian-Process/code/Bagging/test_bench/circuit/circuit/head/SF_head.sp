*OMAMP OPTIMIZATION
.lib 'cmos035.lib' SF
.temp 27
