*OMAMP OPTIMIZATION
.lib 'cmos035.lib' SS
.temp 27
