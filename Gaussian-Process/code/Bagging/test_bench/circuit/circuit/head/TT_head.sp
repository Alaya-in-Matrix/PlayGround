*OMAMP OPTIMIZATION
.lib 'cmos035.lib' TT
.temp 27
