*OMAMP OPTIMIZATION
.lib 'cmos035.lib' FS
.temp 27
