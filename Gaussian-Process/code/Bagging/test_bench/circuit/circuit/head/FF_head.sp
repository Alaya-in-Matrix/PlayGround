*OMAMP OPTIMIZATION
.lib 'cmos035.lib' FF
.temp 27
